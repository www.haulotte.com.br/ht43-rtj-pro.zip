Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-10-26T19:50:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 26 19:50:13 2020 * Host: NICOLASASTAA508 * Database: C:\Users\NICOLA~1\AppData\Local\Temp\{9143F0B6-7EA4-4C93-A123-2AAEFE085FE9}\ifc * Database version: 5507 * Database creation date: Mon Oct 26 19:50:08 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 26 19:50:09 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 26 19:50:09 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HT 132 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HT132-RTJ-PRO_US:HT 132 RTJ PRO:4764344
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Haulotte, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - Black, Working_Area, Metal - Haulotte - White, Metal - Haulotte - Grey Dark, Metal - Haulotte - Red
Type - Autre(Type) - Catégorie: Equipement spécialisé; Machine Weight: 21 400 kg / 47178.92 lb; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HT132-RTJ-PRO_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HT 132 RTJ PRO; Nom du type: HT 132 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ht43-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Articulating Jib: 160°; Batteries: 12 V - 155 Ah; Drive Speed: 5 km/h 0.3km/h / 3.11 mph 0.19 mph; Gradeability: 40%; Ground Clearance: 0.294 m / 11.57 in; Height - Storage / Transport: 3.05 m / 120.08 in; Height - Stowed: 3.05 m / 120.08 in; Horizontal Outreach: 20.2 m / 795.28 in; Jib Length: 2.30 m / 90.55 in; Lenght - Storage/Transport: 12.3 m / 484.25 in; Length - Stowed: 14.8 m / 582.68 in; Lift Capacity: 230-450 kg / 507.06-992.08 lb; Max Ground Pressure of Wheel on Paved Ground: 11.5 daN/cm² - 23554 lbf/cm²; Platform Height: 40.2 m / 1582.68 in; Platform Rotation: +90°/-90°; Platform Size: 2.44x0.915 m / 96.06x36.02 in; Tailswing: 6.3 m / 248.03 in; Tilt: 3°; Tires: 1.1x0.438 m/43.31x17.24 in; Turnable Rotation: 360°; Turning Radius - Inside: 2.750 m / 108.27 in; Turning Radius - Outside: 7.59 m / 298.8 in; Up and Over Clearance: 2.9 m / 114.17 in; Vertical Jib Rotation Angle: -70°/+70°; Wheelbase: 3.5 m / 137.80 in; Width: 2.53 m / 99.61 in; Working Height: 42.2 m / 1661.42 in
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HT 132 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HT132-RTJ-PRO_US: HT 132 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HT132-RTJ-PRO_US: HT 132 RTJ PRO; H: 2.45 m; ID du type: Construction_Aerial-Equipment_Haulotte_HT132-RTJ-PRO_US: HT 132 RTJ PRO; Type: Construction_Aerial-Equipment_Haulotte_HT132-RTJ-PRO_US: HT 132 RTJ PRO
Construction - Axle Extension: yes; Boom Rotation Angle: 73 deg; Jib Rotation Angle: 0 deg; Platform Rotation Angle: 0 deg; Reach Diagram: yes; Telescopic Extend: 37 m; Turnable Rotation: 0 deg; Turning Radius: yes; Vertical Jib Rotation Angle: 70 deg; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 383.604 m2; Volume: 98.8819 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
