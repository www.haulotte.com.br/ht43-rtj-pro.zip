Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-10-26T19:50:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 26 19:50:43 2020 * Host: NICOLASASTAA508 * Database: C:\Users\NICOLA~1\AppData\Local\Temp\{3407AA5A-ADE8-45C5-A395-23AB98C21CC8}\ifc * Database version: 5507 * Database creation date: Mon Oct 26 19:50:38 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 26 19:50:39 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 26 19:50:39 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HT 43 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HT43-RTJ-PRO_FR:HT 43 RTJ PRO:4764332
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Haulotte, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - Black, Working_Area, Metal - Haulotte - White, Metal - Haulotte - Grey Dark, Metal - Haulotte - Red
Type - Autre(Type) - Catégorie: Equipement spécialisé; Batteries: 12 V - 155 Ah; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HT43-RTJ-PRO_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HT 43 RTJ PRO; Nom du type: HT 43 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ht43-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Angle de Levage Pendulaire: -70°/+70°; Angle de Rotation Plateforme: +90°/-90°; Angle de Rotation Tourelle: 360°; Articulation Pendulaire: 160°; Capacité Maximum: 230-450 kg / 507.06-992.08 lb; Déport Arrière: 6.3 m / 248.03 in; Déport Maximum: 20.2 m / 795.28 in; Devers: 3°; Dimensions Plateforme: 2.44x0.915 m / 96.06x36.02 in; Empattement: 3.5 m / 137.80 in; Garde au Sol: 0.294 m / 11.57 in; Hauteur de Transport: 3.05 m / 120.08 in; Hauteur Plateforme: 40.2 m / 1582.68 in; Hauteur Repliée: 3.05 m / 120.08 in; Hauteur Travail: 42.2 m / 1661.42 in; Largeur Hors Tout: 2.53 m / 99.61 in; Longueur de Transport: 12.3 m / 484.25 in; Longueur Hors Tout: 14.8 m / 582.68 in; Longueur Pendulaire: 2.30 m / 90.55 in; Masse Machine (CE): 21 400 kg / 47178.92 lb; Pente Maximum: 40%; Pneus: 1.1x0.438 m/43.31x17.24 in; Point D'articulation: 2.9 m / 114.17 in; Pression Max au Sol: 11.5 daN/cm² - 23554 lbf/cm²; Rayon de Braquage Exterieur: 7.59 m / 298.8 in; Rayon de Braquage Interieur: 2.750 m / 108.27 in; Vitesse de Translation: 5 km/h 0.3km/h / 3.11 mph 0.19 mph
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HT 43 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HT43-RTJ-PRO_FR: HT 43 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HT43-RTJ-PRO_FR: HT 43 RTJ PRO; H: 2.45 m; ID du type: Construction_Aerial-Equipment_Haulotte_HT43-RTJ-PRO_FR: HT 43 RTJ PRO; Type: Construction_Aerial-Equipment_Haulotte_HT43-RTJ-PRO_FR: HT 43 RTJ PRO
Construction - Abaque de Travail: yes; Angle de Levage Flèche: 73 deg; Angle De Levage Pendulaire: 70 deg; Angle De Rotation Pendulaire: 0 deg; Angle De Rotation Plateforme: 0 deg; Angle De Rotation Tourelle: 0 deg; Extension D'essieu: yes; Rayon de Braquage Exterieur: yes; Sortie du Telescope: 37 m; Zone de Travail: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 383.604 m2; Volume: 98.8819 m3
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
